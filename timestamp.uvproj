# Keil uVision project timestamp.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: timestamp
  c flags: SizeSpeed=1
  c include: ..\timestamp
  group timestamp
    ./: test.c
