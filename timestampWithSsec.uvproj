# Keil uVision project timestampWithSsec.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: timestampWithSsec
  c flags: SizeSpeed=1
  c include: ..\timestamp
  group Source Group 1
    ./: test_ssec.c
